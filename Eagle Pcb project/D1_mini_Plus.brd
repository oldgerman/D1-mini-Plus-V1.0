# Repository oldgerman/D1-mini-Plus-V1.0

File README.md:

# D1 mini Plus V1.0

## Top View（The picture is the 2nd circuit board）

A development kit Improved from [D1 mini Pro V1.0.0](https://docs.wemos.cc/en/latest/d1/d1_mini_pro.html)

*Notice：The two pins(pin5 and pin6) of cp2104 are welded together, which is a PCB design problem. The shared PCB file has been modified.
## Add connector & bolts for fixing（All pictures below are the 1st circuit board）

<table>
    <tr>
        <td></td>
	<td>
    </tr>
</table>

## Features

- Pin to pin with D1 mini development kits
- Double-sided PCB layout, the board thickness is 0.8mm, size is 36.0mm x25.6mm
- All components are on one side
- Discrete components are packaged in 0603, which is easy to solder by hand
- There are four M2 holes around the PCB that are easy to fix
- [USB C Connector horizontal In-Board 1.6mm](https://grabcad.com/library/usb-c-connector-horizontal-in-board-1-6mm-1) supports positive and negative insertion
- Leads the TX & RX LEDs  GPIO.0-1 of cp2104, you can use AN721 to turn them on or off
- Use the [USBLC6-2](https://www.st.com/en/protection-devices/usblc6-2.html) ic to ESD protection, If you don't need it, you don't need to solder, this will not affect the serial port work

## Pin Map (Back View)

There is no cartoon logo on the back of the shared PCB file XD

## Designator & Parameter

| Qty  | Value    | Device                    | Package            | Parts                 | Description                                                  |
| ---- | -------- | ------------------------- | ------------------ | --------------------- | ------------------------------------------------------------ |
| 1    | 26MHz    | 3225_CRYSTALL             | 3.2X2.5_KX-7       | U$3                   | EPSON TSX-3225 ±10ppm 9pf                                    |
| 2    | 2.54mm   | CONN_08NO_SILK_FEMALE_PTH | 1X08_NO_SILK       | J1, J2                | 0.1 inch spaced/style header connections                     |
| 1    | U1       | ME6211C33M5G-N            | SOT23-5            | U$1                   | 3.3V 500mA 低差压线性稳压器                                  |
| 1    | 2.4GHz   | RAINSUN_AT9520            | AN9520             | U$4                   | Ceramic antenna 陶瓷天线                                     |
| 1    |          | USB-C_BELOW_BOARD         | USB-C_BLOW_BOARD   | USB-C                 |                                                              |
| 2    | blank    | RESISTOR0603              | 603                | R11, R12              | Generic Resistor Package                                     |
| 1    | 100k     | RESISTOR0603              | 603                | R13                   | Generic Resistor Package                                     |
| 5    | 100nF    | CAP-0603                  | 603                | C4, C7, C12, C13, C14 |                                                              |
| 5    | 10k      | RESISTOR0603              | 603                | R7, R8, R15, R16, R17 | Generic Resistor Package                                     |
| 2    | 10pF     | CAP-0603                  | 603                | C5, C11               |                                                              |
| 1    | 10uF     | CAP-0603                  | 603                | C9                    |                                                              |
| 1    | 12k      | RESISTOR0603              | 603                | R5                    | Generic Resistor Package                                     |
| 3    | 1k       | RESISTOR0603              | 603                | R4, R9, R10           | Generic Resistor Package                                     |
| 1    | 1uF      | CAP-0603                  | 603                | C8                    |                                                              |
| 2    | 1uF/X7R  | CAP-0603                  | 603                | C1, C2                |                                                              |
| 1    | 200      | RESISTOR0603              | 603                | R6                    | Generic Resistor Package                                     |
| 1    | 220k     | RESISTOR0603              | 603                | R14                   | Generic Resistor Package                                     |
| 2    | 4.7uF    | CAP-0603                  | 603                | C3, C6                |                                                              |
| 2    | 470      | RESISTOR0603              | 603                | R2, R3                | Generic Resistor Package                                     |
| 1    | 4k7      | RESISTOR0603              | 603                | R1                    | Generic Resistor Package                                     |
| 1    | 5.6pF    | CAP-0603                  | 603                | C10                   |                                                              |
| 1    | 6V 0.5A  | RESISTOR0603              | 603                | F1                    | Generic Resistor Package                                     |
| 1    | B5819W   | DIODE-SOD323-R            | SOD323-R           | D3                    | Schottky DIODE                                               |
| 3    | BLUE     | LED-BLUE0603              | LED-0603           | D1, D2, D4            | Blue SMD LED                                                 |
| 1    | CP2104   | CP2104                    | QFN24_4MM_SMSC     | U3                    | CP2104 - USB to UART Bridge                                  |
| 1    | ESP8266  | ESP8266                   | QFN32-5X5MM        | U1                    | Espressif ESP8266 WiFi/Microcontroller SoC                   |
| 1    | SWITCH   | MOMENTARY-SWITCH-SPST-SMD | TACTILE_SWITCH_SMD | S1                    | Momentary Switch (Pushbutton) - SPST                         |
| 1    | U2       | UMH3N                     | SOT363             | U$2                   | NPN 100mA 50V Complex Digital Transistors (Bias Resistor Built-in Transistors) |
| 1    | USBLC6-2 | USBLC6-2SOT23-6           | SOT23-6            | U$11                  | low capacitance ESD protection                               |
| 1    | W25Q32FV | W25Q32FVSS                | SOIC-8             | U2                    | W25Q32FV 32Mb (4MB) Serial Flash Memory                      |

## SPI test: ST7789V Graphicstest

Testing in SPI FREQUENCY  40000000

[For more, please see...](https://github.com/Bodmer/TFT_eSPI)

## I2C test: read MPU6050 DMP Euler angles in degrees

<table>
    <tr>
        <td></td>
		<td>
    </tr>
</table>

[For more, please see...](https://github.com/jrowberg/i2cdevlib/tree/master/Arduino/MPU6050)

## ADC0 test: basic NTC thermistor measurement circuit

<table>
    <tr>
        <td></td>
		<td>
    </tr>
</table>

[For more, please see...](https://www.circuitbasics.com/arduino-thermistor-temperature-sensor-tutorial/)

## Wifi scan test

[For more, please see...](https://github.com/esp8266/Arduino/blob/master/libraries/ESP8266WiFi/examples/WiFiScan/WiFiScan.ino)

## CP2104 TX & RX LEDs - How to get them working?

First, download and unzip the AN721: [Download link](https://www.silabs.com/documents/public/example-code/AN721SW.zip), for windows, click in this document

Second, run the CP21xxCustomizationUtility.exe

Third, according to the page 28 from  [AN721: USBXpress™ Device Configuration and Programming Guide](https://www.silabs.com/documents/public/application-notes/AN721.pdf), we set the latch for ticking the GPIO0 and GPIO1;

Click "Program Device" button and wait a minute,the change will be saved in CP2104:

<table>
    <tr>
        <td></td>
		<td>
    </tr>
</table>

Finally, whether you upload a program or use a serial port, the led of CP2104 will flash, enjoy it :joy:

<table>
    <tr>
        <td></td>
		<td>
    </tr>
</table>

## EAGLE design Eagle Pcb project/D1_mini_Plus.brd

Parts:
C1, C2: 1uF/X7R; 0603
C3, C6: 4.7uF; 0603
C4, C7, C12, C13, C14: 100nF; 0603
C5, C11: 10pF; 0603
C8: 1uF; 0603
C9: 10uF; 0603
C10: 5.6pF; 0603
D1, D2, D4: BLUE; LED-0603
D3: B5819W; SOD323-R
F1: 6V 0.5A; 0603
J1, J2: CONN_08NO_SILK_FEMALE_PTH; 1X08_NO_SILK
R1: 4k7; 0603
R2, R3: 470; 0603
R4, R9, R10: 1k; 0603
R5: 12k; 0603
R6: 200; 0603
R7, R8, R15, R16, R17: 10k; 0603
R11, R12: 0603
R13: 100k; 0603
R14: 220k; 0603
S1: SWITCH; TACTILE_SWITCH_SMD_RIGHT_ANGLE
U1: ESP8266; QFN32-5X5MM
U2: W25Q32FV; SOIC-8
U3: CP2104; QFN24_4MM_SMSC
U$1: ME6211C33M5G-N; SOT23-5
U$2: U2; SOT363
U$3: 3225_CRYSTALL; 3.2X2.5_KX-7
U$4: RAINSUN_AT9520; AN9520
U$7, U$8, U$9, U$10: SUN-HOLE_2.1; SUN-HOLE_2.1MM
U$11: USBLC6-2; SOT23-6
USB-C: USB-C_BELOW_BOARD; USB-C_BLOW_BOARD

Connections:
+3V3: C1.1, C3.1, C4.1, C7.1, C8.1, C9.1, C12.1, J2.8, R1.2, R4.1, R7.2, R8.2, R9.1, R10.1, R16.1, R17.1, U1.1 (VDDA), U1.3 (VDD3P3), U1.4 (VDD3P3), U1.11 (VDDPST), U1.17 (VDDPST), U1.29 (VDDD), U1.30 (VDDA), U2.8 (VCC), U3.5 (VIO), U3.6 (VDD), U3.7 (REGIN), U3.8 (VBUS), U$1.5 (OUT)
+5V: C2.1, C14.1, F1.2, J1.1, U$1.1 (IN), U$1.3 (CE), U$11.5
A0: J2.2, R14.2
ADC: R13.2, R14.1, U1.6 (TOUT/ADC)
CP2104_RST: R1.1, U3.9 (#RST)
CP2104_RX: R3.1, U3.20 (RXD)
CP2104_TX\: R2.1, U3.21 (TXD)
DTR: U3.23 (DTR), U$2.2, U$2.4
GND: C1.2, C2.2, C3.2, C4.2, C5.1, C6.2, C7.2, C8.2, C9.2, C11.1, C12.2, C13.1, C14.2, J1.2, R5.1, R11.1, R12.1, R13.1, R15.1, S1.2, U1.GND, U2.4 (GND), U3.2 (GND), U$1.2 (GND), U$3.2, U$3.4, U$11.2, USB-C.GND1 (GND), USB-C.GND2 (GND), USB-C.SHLD1 (SHLD), USB-C.SHLD2 (SHLD), USB-C.SHLD3 (SHLD), USB-C.SHLD4 (SHLD)
GPIO0: J1.4, R16.2, U1.15 (SPICS2/GPIO0), U$2.3
GPIO2: D1.C, J1.3, R17.2, U1.14 (GPIO2)
GPIO3: D4.C, U3.13 (GPIO1/RXLED)
GPIO4: J1.5, U1.16 (GPIO4)
GPIO5: J1.6, U1.24 (GPIO5)
GPIO12: J2.5, U1.10 (MTDI/SPIQ/GPIO12)
GPIO13: J2.6, U1.12 (MTCK/SPID/GPIO13)
GPIO14: J2.4, U1.9 (MTMS/SPICLK/GPIO14)
GPIO15: J2.7, R15.2, U1.13 (MTDO/SPICS/GPIO15)
GPIO16: J2.3, U1.8 (XPD_DCDC/GPIO16)
LNA: C10.1, R11.2, U1.2 (LNA)
LNA1: C10.2, R12.2, U$4.1
unnamed: D1.A, R4.2
unnamed: C6.1, U3.16 (VPP)
unnamed: D2.A, R9.2
unnamed: C5.2, U1.28 (XTAL_IN), U$3.3
unnamed: C11.2, U1.27 (XTAL_OUT), U$3.1
unnamed: R7.1, U1.7 (CHIP_EN)
unnamed: D3.C, F1.1
unnamed: D4.A, R10.2
unnamed: D3.A, USB-C.VBUS1 (VBUS), USB-C.VBUS2 (VBUS)
unnamed: D2.C, U3.14 (GPIO0/TXLED)
unnamed: R6.1, U1.21 (SPICLK/SD_CLK)
RES12K: R5.2, U1.31 (RES12K)
RST: C13.2, J2.1, R8.1, S1.1, U1.32 (EXT_RSTB), U$2.6
RTS: U3.19 (RTS), U$2.1, U$2.5
RX: J1.7, R2.2, U1.25 (U0RXD)
SD_CLK: R6.2, U2.6 (SCK)
SD_CS0: U1.20 (SPICS0/SD_CMD), U2.1 (!CS!)
SD_HD: U1.18 (SPIHD/SD_DATA_2), U2.7 (!HOLD!(D3))
SD_SI: U1.23 (SPID/SD_DATA_1), U2.5 (SI(D0))
SD_SO: U1.22 (SPIQ/SD_DATA_0), U2.2 (SO(D1))
SD_WP: U1.19 (SPIWP/SD_DATA_3), U2.3 (!WP!(D2))
TP: U3.THERM (TP)
TX: J1.8, R3.2, U1.26 (U0TXD)
USB-C_D+: U3.3 (D+), U$11.3, U$11.4, USB-C.A6:D+ (D+), USB-C.B6:D+ (D+)
USB-C_D-: U3.4 (D-), U$11.1, U$11.6, USB-C.A7:D- (D-), USB-C.B7:D- (D-)

Notes on the sheet:
开关去抖电容 Switch eliminates jitter
OldGerman
V1.0.0

Board: 2 copper layers, 35.9 x 25.7 mm, 53 parts (0 on the bottom side), 45 nets.

Other parts of the board:
U$5: OSHW-LOGO-MINI

File Assembly/BOM_D1_mini_Plus.txt (part):

Qty Value    Device                                Package                        Parts                 Description                                                                                                     POPULARITY PROD_ID    SPICEPREFIX VALUE   
1            3225_CRYSTALL                         3.2X2.5_KX-7                   U$3                                                                                                                                                                             
2            CONN_08NO_SILK_FEMALE_PTH             1X08_NO_SILK                   J1, J2                Multi connection point. Often used as Generic Header-pin footprint for 0.1 inch spaced/style header connections            CONN-08438                     
1            ME6211C33M5G-N                        SOT23-5                        U$1                   ME621133M5G-N SOT23-5 3.3V 500mA 低差压线性稳压器                                                                                                                 
1            RAINSUN_AT9520                        AN9520                         U$4                                                                                                                                                                                                                                                                                                                                      
1            USB-C_BELOW_BOARD                     USB-C_BLOW_BOARD               USB-C                                                                                                                                                                           
2            RESISTOR0603                          0603                           R11, R12              Generic Resistor Package                                                                                                                                  
1   100k     RESISTOR0603                          0603                           R13                   Generic Resistor Package                                                                                                                                  
5   100nF    CAP-0603                              0603                           C4, C7, C12, C13, C14                                                                                                                                                           
5   10k      RESISTOR0603                          0603                           R7, R8, R15, R16, R17 Generic Resistor Package                                                                                                                                  
2   10pF     CAP-0603                              0603                           C5, C11                                                                                                                                                                         
1   10uF     CAP-0603                              0603                           C9                                                                                                                                                                              
1   12k      RESISTOR0603                          0603                           R5                    Generic Resistor Package                                                                                                                                  
3   1k       RESISTOR0603                          0603                           R4, R9, R10           Generic Resistor Package                                                                                                                                  
1   1uF      CAP-0603                              0603                           C8                                                                                                                                                                              
2   1uF/X7R  CAP-0603                              0603                           C1, C2                                                                                                                                                                          
1   200      RESISTOR0603                          0603                           R6                    Generic Resistor Package                                                                                                                                  
1   220k     RESISTOR0603                          0603                           R14                   Generic Resistor Package                                                                                                                                  
2   4.7uF    CAP-0603                              0603                           C3, C6                                                                                                                                                                          
2   470      RESISTOR0603                          0603                           R2, R3                Generic Resistor Package                                                                                                                                  
1   4k7      RESISTOR0603                          0603                           R1                    Generic Resistor Package                                                                                                                                  
1   5.6pF    CAP-0603                              0603                           C10                                                                                                                                                                             
1   6V 0.5A  RESISTOR0603                          0603                           F1                    Generic Resistor Package                                                                                                                                  
1   B5819W   DIODE-SOD323-R                        SOD323-R                       D3                    DIODE                                                                                                           4                                         
3   BLUE     LED-BLUE0603                          LED-0603                       D1, D2, D4            Blue SMD LED                                                                                                               DIO-08575              BLUE    
1   CP2104   CP2104                                QFN24_4MM_SMSC                 U3                    CP2104 - USB to UART Bridge                                                                                                           X                   
1   ESP8266  ESP8266                               QFN32-5X5MM                    U1                    Espressif ESP8266 WiFi/Microcontroller SoC                                                                                 IC-12452                       
1   SWITCH   MOMENTARY-SWITCH-SPST-SMD-RIGHT-ANGLE TACTILE_SWITCH_SMD_RIGHT_ANGLE S1                    Momentary Switch (Pushbutton) - SPST                                                                                       COMP-12265                     
1   U2       UMH3N_DUAL_CRYSTAL                    SOT363                         U$2                   sot363                                                                                                                                                    
1   USBLC6-2 USBLC6-2SOT23-6                       SOT23-6                        U$11                                                                                                                                                                            
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
## Commit log

2020-05-12 Create Documents
    images
2021-08-14 Create Example

Notices in the files:
parts and their libraries:
SparkFun-Capacitors: Licensing: Creative Commons ShareAlike 4.0 International - https://creativecommons.org/licenses/by-sa/4.0
microbuilder: This work is placed in the public domain, and may be freely used for commercial and non-commercial work with the following conditions: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
